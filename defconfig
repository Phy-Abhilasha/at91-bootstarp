## defconfig
```kconfig
CONFIG_CONSOLE_INDEX=0
CONFIG_DEBUG=y
CONFIG_DDR_SET_BY_DEVICE=y
CONFIG_SDCARD=y
CONFIG_LOAD_64KB=y
CONFIG_LED_ON_BOARD=y
```
